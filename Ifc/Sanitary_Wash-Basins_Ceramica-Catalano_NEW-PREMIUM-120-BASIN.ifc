Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Wash-Basins_Ceramica-Catalano_NEW-PREMIUM-120-BASIN.ifc
Time: 2021-11-04T12:23:08
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: NEW PREMIUM 120 BASIN
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): NEW PREMIUM 120 BASIN; SKU (BO_prodsku): catalano_basin_newpremium_120x47_cod_112VPN00; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_basin_newpremium_120x47_cod_112VPN00; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_basin_newpremium_120x47_cod_112VPN00; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Wash Basins; BimObjectCategoryCode (BO_bocat_code): wash-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96_15; Uniclass2015Description (BO_uniclass2015_desc): Ceramic sinks; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
